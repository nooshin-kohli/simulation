Commit message: fixed conflicts

File: first_leg/urdf/leg_no_slider.urdf (robot description, URDF)
Before this commit: robot leg, 6 links, 5 joints
Joints:
- joint hip_joint: limit lower=-0.872664625997 upper=1.0471975512 effort=20 velocity=1.6 -> lower=-3.14 upper=3.14 effort=20 velocity=1.6
